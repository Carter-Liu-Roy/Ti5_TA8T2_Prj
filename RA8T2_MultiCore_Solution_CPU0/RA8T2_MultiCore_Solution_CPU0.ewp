# IAR project RA8T2_MultiCore_Solution_CPU0.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: R7KA8T2LF_CPU0 Renesas R7KA8T2LF_CPU0
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 65
  General.FPU2: 7
  ICCARM.IExtraOptions: -f "xcl/rasc_iccarm"
  ICCARM.CCIncludePath2: user
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.AExtraOptionsV2: -f "xcl/rasc_iasmarm"
  OBJCOPY.OOCOutputFile: RA8T2_MultiCore_Solution_CPU0.srec
  ILINK.IlinkOutputFile: RA8T2_MultiCore_Solution_CPU0.out
  ILINK.IlinkIcfFile: script/fsp.icf
  ILINK.IlinkExtraOptions: -f "xcl/rasc_ilinkarm"
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 60
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.IccLang: 0
  group (top)
    ./: buildinfo.ipcf fsp_gen.icf memory_regions.icf
    script/: fsp.icf
  group Flex Software/Build Configuration
    ra_cfg/fsp_cfg/bsp/: board_cfg.h bsp_cfg.h bsp_mcu_device_cfg.h bsp_mcu_device_pn_cfg.h bsp_mcu_family_cfg.h bsp_mcu_ofs_cfg.h bsp_pin_cfg.h
    ra_cfg/fsp_cfg/: r_adc_b_cfg.h r_dmac_cfg.h r_elc_cfg.h r_gpt_cfg.h r_gpt_three_phase_cfg.h r_ioport_cfg.h r_ipc_cfg.h r_sci_b_uart_cfg.h
  group Flex Software/Components
    ra/arm/CMSIS-DSP/Source/BasicMathFunctions/: arm_abs_f16.c arm_abs_f32.c arm_abs_f64.c arm_abs_q15.c arm_abs_q31.c arm_abs_q7.c arm_add_f16.c arm_add_f32.c arm_add_f64.c arm_add_q15.c arm_add_q31.c arm_add_q7.c arm_and_u16.c arm_and_u32.c arm_and_u8.c arm_clip_f16.c arm_clip_f32.c arm_clip_q15.c arm_clip_q31.c arm_clip_q7.c arm_dot_prod_f16.c arm_dot_prod_f32.c arm_dot_prod_f64.c arm_dot_prod_q15.c arm_dot_prod_q31.c arm_dot_prod_q7.c arm_mult_f16.c arm_mult_f32.c arm_mult_f64.c arm_mult_q15.c arm_mult_q31.c arm_mult_q7.c arm_negate_f16.c arm_negate_f32.c arm_negate_f64.c arm_negate_q15.c arm_negate_q31.c arm_negate_q7.c arm_not_u16.c arm_not_u32.c arm_not_u8.c arm_offset_f16.c arm_offset_f32.c arm_offset_f64.c arm_offset_q15.c arm_offset_q31.c arm_offset_q7.c arm_or_u16.c arm_or_u32.c arm_or_u8.c arm_scale_f16.c arm_scale_f32.c arm_scale_f64.c arm_scale_q15.c arm_scale_q31.c arm_scale_q7.c arm_shift_q15.c arm_shift_q31.c arm_shift_q7.c arm_sub_f16.c arm_sub_f32.c arm_sub_f64.c arm_sub_q15.c arm_sub_q31.c arm_sub_q7.c arm_xor_u16.c arm_xor_u32.c arm_xor_u8.c Config.cmake
    ra/arm/CMSIS-DSP/Source/StatisticsFunctions/: arm_absmax_f16.c arm_absmax_f32.c arm_absmax_f64.c arm_absmax_no_idx_f16.c arm_absmax_no_idx_f32.c arm_absmax_no_idx_f64.c arm_absmax_no_idx_q15.c arm_absmax_no_idx_q31.c arm_absmax_no_idx_q7.c arm_absmax_q15.c arm_absmax_q31.c arm_absmax_q7.c arm_absmin_f16.c arm_absmin_f32.c arm_absmin_f64.c arm_absmin_no_idx_f16.c arm_absmin_no_idx_f32.c arm_absmin_no_idx_f64.c arm_absmin_no_idx_q15.c arm_absmin_no_idx_q31.c arm_absmin_no_idx_q7.c arm_absmin_q15.c arm_absmin_q31.c arm_absmin_q7.c arm_accumulate_f16.c arm_accumulate_f32.c arm_accumulate_f64.c arm_entropy_f16.c arm_entropy_f32.c arm_entropy_f64.c arm_kullback_leibler_f16.c arm_kullback_leibler_f32.c arm_kullback_leibler_f64.c arm_logsumexp_dot_prod_f16.c arm_logsumexp_dot_prod_f32.c arm_logsumexp_f16.c arm_logsumexp_f32.c arm_max_f16.c arm_max_f32.c arm_max_f64.c arm_max_no_idx_f16.c arm_max_no_idx_f32.c arm_max_no_idx_f64.c arm_max_no_idx_q15.c arm_max_no_idx_q31.c arm_max_no_idx_q7.c arm_max_q15.c arm_max_q31.c arm_max_q7.c arm_mean_f16.c arm_mean_f32.c arm_mean_f64.c arm_mean_q15.c arm_mean_q31.c arm_mean_q7.c arm_min_f16.c arm_min_f32.c arm_min_f64.c arm_min_no_idx_f16.c arm_min_no_idx_f32.c arm_min_no_idx_f64.c arm_min_no_idx_q15.c arm_min_no_idx_q31.c arm_min_no_idx_q7.c arm_min_q15.c arm_min_q31.c arm_min_q7.c arm_mse_f16.c arm_mse_f32.c arm_mse_f64.c arm_mse_q15.c arm_mse_q31.c arm_mse_q7.c arm_power_f16.c arm_power_f32.c arm_power_f64.c arm_power_q15.c arm_power_q31.c arm_power_q7.c arm_rms_f16.c arm_rms_f32.c arm_rms_q15.c arm_rms_q31.c arm_std_f16.c arm_std_f32.c arm_std_f64.c arm_std_q15.c arm_std_q31.c arm_var_f16.c arm_var_f32.c arm_var_f64.c arm_var_q15.c arm_var_q31.c Config.cmake
    ra/arm/CMSIS-DSP/Source/FastMathFunctions/: arm_atan2_f16.c arm_atan2_f32.c arm_atan2_q15.c arm_atan2_q31.c arm_cos_f32.c arm_cos_q15.c arm_cos_q31.c arm_divide_q15.c arm_divide_q31.c arm_sin_f32.c arm_sin_q15.c arm_sin_q31.c arm_sqrt_q15.c arm_sqrt_q31.c arm_vexp_f16.c arm_vexp_f32.c arm_vexp_f64.c arm_vinverse_f16.c arm_vlog_f16.c arm_vlog_f32.c arm_vlog_f64.c arm_vlog_q15.c arm_vlog_q31.c Config.cmake
    ra/arm/CMSIS-DSP/Source/WindowFunctions/: arm_bartlett_f32.c arm_bartlett_f64.c arm_blackman_harris_92db_f32.c arm_blackman_harris_92db_f64.c arm_hamming_f32.c arm_hamming_f64.c arm_hanning_f32.c arm_hanning_f64.c arm_hft116d_f32.c arm_hft116d_f64.c arm_hft144d_f32.c arm_hft144d_f64.c arm_hft169d_f32.c arm_hft169d_f64.c arm_hft196d_f32.c arm_hft196d_f64.c arm_hft223d_f32.c arm_hft223d_f64.c arm_hft248d_f32.c arm_hft248d_f64.c arm_hft90d_f32.c arm_hft90d_f64.c arm_hft95_f32.c arm_hft95_f64.c arm_nuttall3_f32.c arm_nuttall3_f64.c arm_nuttall3a_f32.c arm_nuttall3a_f64.c arm_nuttall3b_f32.c arm_nuttall3b_f64.c arm_nuttall4_f32.c arm_nuttall4_f64.c arm_nuttall4a_f32.c arm_nuttall4a_f64.c arm_nuttall4b_f32.c arm_nuttall4b_f64.c arm_nuttall4c_f32.c arm_nuttall4c_f64.c arm_welch_f32.c arm_welch_f64.c Config.cmake
    ra/arm/CMSIS-DSP/Source/SupportFunctions/: arm_barycenter_f16.c arm_barycenter_f32.c arm_bitonic_sort_f32.c arm_bubble_sort_f32.c arm_copy_f16.c arm_copy_f32.c arm_copy_f64.c arm_copy_q15.c arm_copy_q31.c arm_copy_q7.c arm_f16_to_f64.c arm_f16_to_float.c arm_f16_to_q15.c arm_f64_to_f16.c arm_f64_to_float.c arm_f64_to_q15.c arm_f64_to_q31.c arm_f64_to_q7.c arm_fill_f16.c arm_fill_f32.c arm_fill_f64.c arm_fill_q15.c arm_fill_q31.c arm_fill_q7.c arm_float_to_f16.c arm_float_to_f64.c arm_float_to_q15.c arm_float_to_q31.c arm_float_to_q7.c arm_heap_sort_f32.c arm_insertion_sort_f32.c arm_merge_sort_f32.c arm_merge_sort_init_f32.c arm_q15_to_f16.c arm_q15_to_f64.c arm_q15_to_float.c arm_q15_to_q31.c arm_q15_to_q7.c arm_q31_to_f64.c arm_q31_to_float.c arm_q31_to_q15.c arm_q31_to_q7.c arm_q7_to_f64.c arm_q7_to_float.c arm_q7_to_q15.c arm_q7_to_q31.c arm_quick_sort_f32.c arm_selection_sort_f32.c arm_sort_f32.c arm_sort_init_f32.c arm_weighted_average_f16.c arm_weighted_average_f32.c Config.cmake
    ra/arm/CMSIS-DSP/Source/InterpolationFunctions/: arm_bilinear_interp_f16.c arm_bilinear_interp_f32.c arm_bilinear_interp_q15.c arm_bilinear_interp_q31.c arm_bilinear_interp_q7.c arm_linear_interp_f16.c arm_linear_interp_f32.c arm_linear_interp_q15.c arm_linear_interp_q31.c arm_linear_interp_q7.c arm_spline_interp_f32.c arm_spline_interp_init_f32.c Config.cmake
    ra/arm/CMSIS-DSP/Source/FilteringFunctions/: arm_biquad_cascade_df1_32x64_init_q31.c arm_biquad_cascade_df1_32x64_q31.c arm_biquad_cascade_df1_f16.c arm_biquad_cascade_df1_f32.c arm_biquad_cascade_df1_fast_q15.c arm_biquad_cascade_df1_fast_q31.c arm_biquad_cascade_df1_init_f16.c arm_biquad_cascade_df1_init_f32.c arm_biquad_cascade_df1_init_q15.c arm_biquad_cascade_df1_init_q31.c arm_biquad_cascade_df1_q15.c arm_biquad_cascade_df1_q31.c arm_biquad_cascade_df2T_f16.c arm_biquad_cascade_df2T_f32.c arm_biquad_cascade_df2T_f64.c arm_biquad_cascade_df2T_init_f16.c arm_biquad_cascade_df2T_init_f32.c arm_biquad_cascade_df2T_init_f64.c arm_biquad_cascade_stereo_df2T_f16.c arm_biquad_cascade_stereo_df2T_f32.c arm_biquad_cascade_stereo_df2T_init_f16.c arm_biquad_cascade_stereo_df2T_init_f32.c arm_conv_f32.c arm_conv_fast_opt_q15.c arm_conv_fast_q15.c arm_conv_fast_q31.c arm_conv_opt_q15.c arm_conv_opt_q7.c arm_conv_partial_f32.c arm_conv_partial_fast_opt_q15.c arm_conv_partial_fast_q15.c arm_conv_partial_fast_q31.c arm_conv_partial_opt_q15.c arm_conv_partial_opt_q7.c arm_conv_partial_q15.c arm_conv_partial_q31.c arm_conv_partial_q7.c arm_conv_q15.c arm_conv_q31.c arm_conv_q7.c arm_correlate_f16.c arm_correlate_f32.c arm_correlate_f64.c arm_correlate_fast_opt_q15.c arm_correlate_fast_q15.c arm_correlate_fast_q31.c arm_correlate_opt_q15.c arm_correlate_opt_q7.c arm_correlate_q15.c arm_correlate_q31.c arm_correlate_q7.c arm_fir_decimate_f32.c arm_fir_decimate_f64.c arm_fir_decimate_fast_q15.c arm_fir_decimate_fast_q31.c arm_fir_decimate_init_f32.c arm_fir_decimate_init_f64.c arm_fir_decimate_init_q15.c arm_fir_decimate_init_q31.c arm_fir_decimate_q15.c arm_fir_decimate_q31.c arm_fir_f16.c arm_fir_f32.c arm_fir_f64.c arm_fir_fast_q15.c arm_fir_fast_q31.c arm_fir_init_f16.c arm_fir_init_f32.c arm_fir_init_f64.c arm_fir_init_q15.c arm_fir_init_q31.c arm_fir_init_q7.c arm_fir_interpolate_f32.c arm_fir_interpolate_init_f32.c arm_fir_interpolate_init_q15.c arm_fir_interpolate_init_q31.c arm_fir_interpolate_q15.c arm_fir_interpolate_q31.c arm_fir_lattice_f32.c arm_fir_lattice_init_f32.c arm_fir_lattice_init_q15.c arm_fir_lattice_init_q31.c arm_fir_lattice_q15.c arm_fir_lattice_q31.c arm_fir_q15.c arm_fir_q31.c arm_fir_q7.c arm_fir_sparse_f32.c arm_fir_sparse_init_f32.c arm_fir_sparse_init_q15.c arm_fir_sparse_init_q31.c arm_fir_sparse_init_q7.c arm_fir_sparse_q15.c arm_fir_sparse_q31.c arm_fir_sparse_q7.c arm_iir_lattice_f32.c arm_iir_lattice_init_f32.c arm_iir_lattice_init_q15.c arm_iir_lattice_init_q31.c arm_iir_lattice_q15.c arm_iir_lattice_q31.c arm_levinson_durbin_f16.c arm_levinson_durbin_f32.c arm_levinson_durbin_q31.c arm_lms_f32.c arm_lms_init_f32.c arm_lms_init_q15.c arm_lms_init_q31.c arm_lms_norm_f32.c arm_lms_norm_init_f32.c arm_lms_norm_init_q15.c arm_lms_norm_init_q31.c arm_lms_norm_q15.c arm_lms_norm_q31.c arm_lms_q15.c arm_lms_q31.c Config.cmake
    ra/arm/CMSIS-DSP/Source/TransformFunctions/: arm_bitreversal.c arm_bitreversal2.c arm_bitreversal_f16.c arm_cfft_f16.c arm_cfft_f32.c arm_cfft_f64.c arm_cfft_init_f16.c arm_cfft_init_f32.c arm_cfft_init_f64.c arm_cfft_init_q15.c arm_cfft_init_q31.c arm_cfft_q15.c arm_cfft_q31.c arm_cfft_radix2_f16.c arm_cfft_radix2_f32.c arm_cfft_radix2_init_f16.c arm_cfft_radix2_init_f32.c arm_cfft_radix2_init_q15.c arm_cfft_radix2_init_q31.c arm_cfft_radix2_q15.c arm_cfft_radix2_q31.c arm_cfft_radix4_f16.c arm_cfft_radix4_f32.c arm_cfft_radix4_init_f16.c arm_cfft_radix4_init_f32.c arm_cfft_radix4_init_q15.c arm_cfft_radix4_init_q31.c arm_cfft_radix4_q15.c arm_cfft_radix4_q31.c arm_cfft_radix8_f16.c arm_cfft_radix8_f32.c arm_dct4_f32.c arm_dct4_init_f32.c arm_dct4_init_q15.c arm_dct4_init_q31.c arm_dct4_q15.c arm_dct4_q31.c arm_mfcc_f16.c arm_mfcc_f32.c arm_mfcc_init_f16.c arm_mfcc_init_f32.c arm_mfcc_init_q15.c arm_mfcc_init_q31.c arm_mfcc_q15.c arm_mfcc_q31.c arm_rfft_f32.c arm_rfft_fast_f16.c arm_rfft_fast_f32.c arm_rfft_fast_f64.c arm_rfft_fast_init_f16.c arm_rfft_fast_init_f32.c arm_rfft_fast_init_f64.c arm_rfft_init_f32.c arm_rfft_init_q15.c arm_rfft_init_q31.c arm_rfft_q15.c arm_rfft_q31.c Config.cmake
    ra/arm/CMSIS-DSP/Source/DistanceFunctions/: arm_boolean_distance.c arm_boolean_distance_template.h arm_braycurtis_distance_f16.c arm_braycurtis_distance_f32.c arm_canberra_distance_f16.c arm_canberra_distance_f32.c arm_chebyshev_distance_f16.c arm_chebyshev_distance_f32.c arm_chebyshev_distance_f64.c arm_cityblock_distance_f16.c arm_cityblock_distance_f32.c arm_cityblock_distance_f64.c arm_correlation_distance_f16.c arm_correlation_distance_f32.c arm_cosine_distance_f16.c arm_cosine_distance_f32.c arm_cosine_distance_f64.c arm_dice_distance.c arm_dtw_distance_f32.c arm_dtw_init_window_q7.c arm_dtw_path_f32.c arm_euclidean_distance_f16.c arm_euclidean_distance_f32.c arm_euclidean_distance_f64.c arm_hamming_distance.c arm_jaccard_distance.c arm_jensenshannon_distance_f16.c arm_jensenshannon_distance_f32.c arm_kulsinski_distance.c arm_minkowski_distance_f16.c arm_minkowski_distance_f32.c arm_rogerstanimoto_distance.c arm_russellrao_distance.c arm_sokalmichener_distance.c arm_sokalsneath_distance.c arm_yule_distance.c Config.cmake
    ra/arm/CMSIS-DSP/Source/ComplexMathFunctions/: arm_cmplx_conj_f16.c arm_cmplx_conj_f32.c arm_cmplx_conj_q15.c arm_cmplx_conj_q31.c arm_cmplx_dot_prod_f16.c arm_cmplx_dot_prod_f32.c arm_cmplx_dot_prod_q15.c arm_cmplx_dot_prod_q31.c arm_cmplx_mag_f16.c arm_cmplx_mag_f32.c arm_cmplx_mag_f64.c arm_cmplx_mag_fast_q15.c arm_cmplx_mag_q15.c arm_cmplx_mag_q31.c arm_cmplx_mag_squared_f16.c arm_cmplx_mag_squared_f32.c arm_cmplx_mag_squared_f64.c arm_cmplx_mag_squared_q15.c arm_cmplx_mag_squared_q31.c arm_cmplx_mult_cmplx_f16.c arm_cmplx_mult_cmplx_f32.c arm_cmplx_mult_cmplx_f64.c arm_cmplx_mult_cmplx_q15.c arm_cmplx_mult_cmplx_q31.c arm_cmplx_mult_real_f16.c arm_cmplx_mult_real_f32.c arm_cmplx_mult_real_q15.c arm_cmplx_mult_real_q31.c Config.cmake
    ra/arm/CMSIS-DSP/Source/CommonTables/: arm_common_tables.c arm_common_tables_f16.c arm_const_structs.c arm_const_structs_f16.c arm_mve_tables.c arm_mve_tables_f16.c Config.cmake
    ra/arm/CMSIS-DSP/Include/: arm_common_tables.h arm_common_tables_f16.h arm_const_structs.h arm_const_structs_f16.h arm_helium_utils.h arm_math.h arm_math_f16.h arm_math_memory.h arm_math_types.h arm_math_types_f16.h arm_mve_tables.h arm_mve_tables_f16.h arm_vec_math.h arm_vec_math_f16.h
    ra/arm/CMSIS-DSP/Source/BayesFunctions/: arm_gaussian_naive_bayes_predict_f16.c arm_gaussian_naive_bayes_predict_f32.c Config.cmake
    ra/arm/CMSIS-DSP/Source/MatrixFunctions/: arm_householder_f16.c arm_householder_f32.c arm_householder_f64.c arm_mat_add_f16.c arm_mat_add_f32.c arm_mat_add_q15.c arm_mat_add_q31.c arm_mat_cholesky_f16.c arm_mat_cholesky_f32.c arm_mat_cholesky_f64.c arm_mat_cmplx_mult_f16.c arm_mat_cmplx_mult_f32.c arm_mat_cmplx_mult_q15.c arm_mat_cmplx_mult_q31.c arm_mat_cmplx_trans_f16.c arm_mat_cmplx_trans_f32.c arm_mat_cmplx_trans_q15.c arm_mat_cmplx_trans_q31.c arm_mat_init_f16.c arm_mat_init_f32.c arm_mat_init_f64.c arm_mat_init_q15.c arm_mat_init_q31.c arm_mat_inverse_f16.c arm_mat_inverse_f32.c arm_mat_inverse_f64.c arm_mat_ldlt_f32.c arm_mat_ldlt_f64.c arm_mat_mult_f16.c arm_mat_mult_f32.c arm_mat_mult_f64.c arm_mat_mult_fast_q15.c arm_mat_mult_fast_q31.c arm_mat_mult_opt_q31.c arm_mat_mult_q15.c arm_mat_mult_q31.c arm_mat_mult_q7.c arm_mat_qr_f16.c arm_mat_qr_f32.c arm_mat_qr_f64.c arm_mat_scale_f16.c arm_mat_scale_f32.c arm_mat_scale_q15.c arm_mat_scale_q31.c arm_mat_solve_lower_triangular_f16.c arm_mat_solve_lower_triangular_f32.c arm_mat_solve_lower_triangular_f64.c arm_mat_solve_upper_triangular_f16.c arm_mat_solve_upper_triangular_f32.c arm_mat_solve_upper_triangular_f64.c arm_mat_sub_f16.c arm_mat_sub_f32.c arm_mat_sub_f64.c arm_mat_sub_q15.c arm_mat_sub_q31.c arm_mat_trans_f16.c arm_mat_trans_f32.c arm_mat_trans_f64.c arm_mat_trans_q15.c arm_mat_trans_q31.c arm_mat_trans_q7.c arm_mat_vec_mult_f16.c arm_mat_vec_mult_f32.c arm_mat_vec_mult_q15.c arm_mat_vec_mult_q31.c arm_mat_vec_mult_q7.c Config.cmake
    ra/arm/CMSIS-DSP/Source/ControllerFunctions/: arm_pid_init_f32.c arm_pid_init_q15.c arm_pid_init_q31.c arm_pid_reset_f32.c arm_pid_reset_q15.c arm_pid_reset_q31.c arm_sin_cos_f32.c arm_sin_cos_q31.c Config.cmake
    ra/arm/CMSIS-DSP/Source/QuaternionMathFunctions/: arm_quaternion2rotation_f32.c arm_quaternion_conjugate_f32.c arm_quaternion_inverse_f32.c arm_quaternion_norm_f32.c arm_quaternion_normalize_f32.c arm_quaternion_product_f32.c arm_quaternion_product_single_f32.c arm_rotation2quaternion_f32.c Config.cmake
    ra/arm/CMSIS-DSP/PrivateInclude/: arm_sorting.h arm_vec_fft.h arm_vec_filtering.h
    ra/arm/CMSIS-DSP/Source/SVMFunctions/: arm_svm_linear_init_f16.c arm_svm_linear_init_f32.c arm_svm_linear_predict_f16.c arm_svm_linear_predict_f32.c arm_svm_polynomial_init_f16.c arm_svm_polynomial_init_f32.c arm_svm_polynomial_predict_f16.c arm_svm_polynomial_predict_f32.c arm_svm_rbf_init_f16.c arm_svm_rbf_init_f32.c arm_svm_rbf_predict_f16.c arm_svm_rbf_predict_f32.c arm_svm_sigmoid_init_f16.c arm_svm_sigmoid_init_f32.c arm_svm_sigmoid_predict_f16.c arm_svm_sigmoid_predict_f32.c Config.cmake
    ra/arm/CMSIS_6/CMSIS/Core/Include/m-profile/: armv7m_cachel1.h armv7m_mpu.h armv81m_pac.h armv8m_mpu.h armv8m_pmu.h cmsis_armclang_m.h cmsis_clang_m.h cmsis_gcc_m.h cmsis_iccarm_m.h cmsis_tiarmclang_m.h
    ra/arm/CMSIS-DSP/Include/dsp/: basic_math_functions.h basic_math_functions_f16.h bayes_functions.h bayes_functions_f16.h complex_math_functions.h complex_math_functions_f16.h controller_functions.h controller_functions_f16.h debug.h distance_functions.h distance_functions_f16.h fast_math_functions.h fast_math_functions_f16.h filtering_functions.h filtering_functions_f16.h interpolation_functions.h interpolation_functions_f16.h matrix_functions.h matrix_functions_f16.h matrix_utils.h none.h quaternion_math_functions.h statistics_functions.h statistics_functions_f16.h support_functions.h support_functions_f16.h svm_defines.h svm_functions.h svm_functions_f16.h transform_functions.h transform_functions_f16.h utils.h window_functions.h
    ra/fsp/inc/api/: bsp_api.h fsp_common_api.h r_adc_api.h r_elc_api.h r_ioport_api.h r_ipc_api.h r_three_phase_api.h r_timer_api.h r_transfer_api.h r_uart_api.h
    ra/fsp/src/bsp/mcu/all/: bsp_clocks.c bsp_clocks.h bsp_common.c bsp_common.h bsp_compiler_support.h bsp_delay.c bsp_delay.h bsp_exceptions.h bsp_group_irq.c bsp_group_irq.h bsp_guard.c bsp_guard.h bsp_io.c bsp_io.h bsp_ipc.c bsp_ipc.h bsp_irq.c bsp_irq.h bsp_macl.c bsp_macl.h bsp_mcu_api.h bsp_mmf.h bsp_module_stop.h bsp_ospi_b.c bsp_ospi_b.h bsp_register_protection.c bsp_register_protection.h bsp_sbrk.c bsp_sdram.c bsp_sdram.h bsp_security.c bsp_security.h bsp_tfu.h
    ra/fsp/src/bsp/mcu/ra8t2/: bsp_elc.h bsp_feature.h bsp_linker.c bsp_mcu_info.h bsp_override.h bsp_peripheral.h r_adc_device_types.h
    ra/arm/CMSIS-DSP/Source/: CMakeLists.txt configDsp.cmake Makefile
    ra/arm/CMSIS_6/CMSIS/Core/Include/: cmsis_armclang.h cmsis_clang.h cmsis_compiler.h cmsis_gcc.h cmsis_version.h core_ca.h core_cm0.h core_cm0plus.h core_cm1.h core_cm23.h core_cm3.h core_cm33.h core_cm35p.h core_cm4.h core_cm52.h core_cm55.h core_cm7.h core_cm85.h core_sc000.h core_sc300.h core_starmc1.h tz_context.h
    ra/arm/CMSIS_6/CMSIS/Core/Include/a-profile/: cmsis_armclang_a.h cmsis_clang_a.h cmsis_cp15.h cmsis_gcc_a.h cmsis_iccarm_a.h irq_ctrl.h
    ra/arm/CMSIS_6/CMSIS/Core/Include/r-profile/: cmsis_armclang_r.h cmsis_clang_r.h cmsis_gcc_r.h
    ra/fsp/inc/: fsp_features.h fsp_version.h
    ra/arm/CMSIS_6/: LICENSE
    ra/fsp/src/bsp/cmsis/Device/RENESAS/Include/: R7KA8T2LF_core0.h R7KA8T2LF_core1.h renesas.h system.h
    ra/fsp/src/r_adc_b/: r_adc_b.c
    ra/fsp/inc/instances/: r_adc_b.h r_dmac.h r_elc.h r_gpt.h r_gpt_three_phase.h r_ioport.h r_ipc.h r_sci_b_uart.h
    ra/fsp/src/r_dmac/: r_dmac.c
    ra/fsp/src/r_elc/: r_elc.c
    ra/fsp/src/r_gpt/: r_gpt.c
    ra/fsp/src/r_gpt_three_phase/: r_gpt_three_phase.c
    ra/fsp/src/r_ioport/: r_ioport.c
    ra/fsp/src/r_ipc/: r_ipc.c
    ra/fsp/src/r_sci_b_uart/: r_sci_b_uart.c
    ra/fsp/src/bsp/cmsis/Device/RENESAS/Source/: startup.c system.c
  group Flex Software/Generated Data
    ra_gen/: bsp_clock_cfg.h common_data.c common_data.h elc_data.c hal_data.c hal_data.h main.c pin_data.c vector_data.c vector_data.h
  group Flex Software/Program Entry
    src/: hal_entry.c hal_warmstart.c
  group userApp
    user/: mc_math.c mc_math.h
