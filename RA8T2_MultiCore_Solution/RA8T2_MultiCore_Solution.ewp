# IAR project RA8T2_MultiCore_Solution.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: R7KA8T2LF_CPU0 Renesas R7KA8T2LF_CPU0
  General.CoreVariant: 65
  General.FPU2: 7
  ICCARM.IExtraOptions: -f "xcl/rasc_iccarm"
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.AExtraOptionsV2: -f "xcl/rasc_iasmarm"
  ILINK.IlinkOutputFile: RA8T2_MultiCore_Solution.out
  ILINK.IlinkIcfFile: null
  ILINK.IlinkExtraOptions: -f "xcl/rasc_ilinkarm"
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 60
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.IccLang: 0
  group (top)
    ./: buildinfo.ipcf
