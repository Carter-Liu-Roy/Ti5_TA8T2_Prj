# IAR project CPU1_Debug.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: R7KA8T2LF_CPU1 Renesas R7KA8T2LF_CPU1
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 61
  General.FPU2: 6
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: CPU1_Debug.out
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ../RA8T2_MultiCore_Solution_CPU1/Debug/Exe/: RA8T2_MultiCore_Solution_CPU1.out
