<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\CPU1_Debug.ewp</path>
    </project>
    <batchBuild />
</workspace>
