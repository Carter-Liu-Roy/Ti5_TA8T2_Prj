<?xml version="1.0" encoding="UTF-8" standalone="yes"?>
<workspace>
    <project>
        <path>$WS_DIR$\RA8T2_MultiCore_Solution_CPU1.ewp</path>
    </project>
    <batchBuild/>
</workspace>
