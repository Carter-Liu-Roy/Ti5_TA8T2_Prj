# IAR project RA8T2_MultiCore_Solution_CPU1.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: R7KA8T2LF_CPU1 Renesas R7KA8T2LF_CPU1
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 61
  General.FPU2: 0
  ICCARM.IExtraOptions: -f "xcl/rasc_iccarm"
  ICCARM.CCIncludePath2: src\beckhoff\Src; src\renesas; src\phy_management
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.AExtraOptionsV2: -f "xcl/rasc_iasmarm"
  OBJCOPY.OOCOutputFile: RA8T2_MultiCore_Solution_CPU1.srec
  ILINK.IlinkOutputFile: RA8T2_MultiCore_Solution_CPU1.out
  ILINK.IlinkIcfFile: script/fsp.icf
  ILINK.IlinkExtraOptions: -f "xcl/rasc_ilinkarm"
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 60
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.IccLang: 0
  group (top)
    ./: buildinfo.ipcf
  group Flex Software/Build Configuration
    ra_cfg/fsp_cfg/bsp/: board_cfg.h bsp_cfg.h bsp_mcu_device_cfg.h bsp_mcu_device_pn_cfg.h bsp_mcu_family_cfg.h bsp_mcu_ofs_cfg.h bsp_pin_cfg.h
    ra_cfg/fsp_cfg/: r_agt_cfg.h r_ethercat_phy_cfg.h r_ioport_cfg.h r_ipc_cfg.h renesashw.h rm_ethercat_ssc_port_cfg.h
  group Flex Software/Components
    ra/arm/CMSIS_6/CMSIS/Core/Include/m-profile/: armv7m_cachel1.h armv7m_mpu.h armv81m_pac.h armv8m_mpu.h armv8m_pmu.h cmsis_armclang_m.h cmsis_clang_m.h cmsis_gcc_m.h cmsis_iccarm_m.h cmsis_tiarmclang_m.h
    ra/fsp/inc/api/: bsp_api.h fsp_common_api.h r_ether_phy_api.h r_ioport_api.h r_ipc_api.h r_timer_api.h rm_ethercat_ssc_port_api.h
    ra/fsp/src/bsp/mcu/all/: bsp_clocks.c bsp_clocks.h bsp_common.c bsp_common.h bsp_compiler_support.h bsp_delay.c bsp_delay.h bsp_exceptions.h bsp_group_irq.c bsp_group_irq.h bsp_guard.c bsp_guard.h bsp_io.c bsp_io.h bsp_ipc.c bsp_ipc.h bsp_irq.c bsp_irq.h bsp_macl.c bsp_macl.h bsp_mcu_api.h bsp_mmf.h bsp_module_stop.h bsp_ospi_b.c bsp_ospi_b.h bsp_register_protection.c bsp_register_protection.h bsp_sbrk.c bsp_sdram.c bsp_sdram.h bsp_security.c bsp_security.h bsp_tfu.h
    ra/fsp/src/bsp/mcu/ra8t2/: bsp_elc.h bsp_feature.h bsp_linker.c bsp_mcu_info.h bsp_override.h bsp_peripheral.h r_adc_device_types.h
    ra/arm/CMSIS_6/CMSIS/Core/Include/: cmsis_armclang.h cmsis_clang.h cmsis_compiler.h cmsis_gcc.h cmsis_version.h core_ca.h core_cm0.h core_cm0plus.h core_cm1.h core_cm23.h core_cm3.h core_cm33.h core_cm35p.h core_cm4.h core_cm52.h core_cm55.h core_cm7.h core_cm85.h core_sc000.h core_sc300.h core_starmc1.h tz_context.h
    ra/arm/CMSIS_6/CMSIS/Core/Include/a-profile/: cmsis_armclang_a.h cmsis_clang_a.h cmsis_cp15.h cmsis_gcc_a.h cmsis_iccarm_a.h irq_ctrl.h
    ra/arm/CMSIS_6/CMSIS/Core/Include/r-profile/: cmsis_armclang_r.h cmsis_clang_r.h cmsis_gcc_r.h
    ra/fsp/inc/: fsp_features.h fsp_version.h
    ra/arm/CMSIS_6/: LICENSE
    ra/fsp/src/bsp/cmsis/Device/RENESAS/Include/: R7KA8T2LF_core0.h R7KA8T2LF_core1.h renesas.h system.h
    ra/fsp/src/r_agt/: r_agt.c
    ra/fsp/inc/instances/: r_agt.h r_ethercat_phy.h r_ioport.h r_ipc.h rm_ethercat_ssc_port.h
    ra/fsp/src/r_ethercat_phy/: r_ethercat_phy.c
    ra/fsp/src/r_ethercat_phy/targets/ICS1894/: r_ethercat_phy_target_ics1894.c
    ra/fsp/src/r_ioport/: r_ioport.c
    ra/fsp/src/r_ipc/: r_ipc.c
    ra/fsp/src/rm_ethercat_ssc_port/: rm_ethercat_ssc_port.c
    ra/fsp/src/bsp/cmsis/Device/RENESAS/Source/: startup.c system.c
  group Flex Software/Generated Data
    ra_gen/: bsp_clock_cfg.h common_data.c common_data.h hal_data.c hal_data.h main.c pin_data.c vector_data.c vector_data.h
  group Flex Software/Program Entry
    src/beckhoff/Src/: applInterface.h cia402appl.c cia402appl.h coeappl.c coeappl.h ecat_def.h ecatappl.c ecatappl.h ecatcoe.c ecatcoe.h ecatslv.c ecatslv.h esc.h mailbox.c mailbox.h objdef.c objdef.h sdoserv.c sdoserv.h
    src/renesas/: cia402sample.c cia402sample.h
    src/: hal_entry.c hal_warmstart.c
